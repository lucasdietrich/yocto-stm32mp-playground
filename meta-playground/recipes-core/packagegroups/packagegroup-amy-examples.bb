SUMMARY = "Amy examples package group"
LICENSE = "CLOSED"

inherit packagegroup

# populate here
RDEPENDS:${PN} = "\
    rust-example \
"