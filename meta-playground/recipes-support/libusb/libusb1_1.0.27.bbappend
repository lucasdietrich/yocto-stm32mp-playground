FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-USB-DFU-Change-MAX_CTRL_BUFFER_LENGTH-from-4KB-to-32.patch"

