FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Remove-4KB-transfer_size-check-for-linux-platform-le.patch"

