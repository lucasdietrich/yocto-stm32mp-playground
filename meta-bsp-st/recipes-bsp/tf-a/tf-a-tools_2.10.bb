require tf-a-tools.inc

LICENSE = "BSD-3-Clause"
LIC_FILES_CHKSUM = "file://docs/license.rst;md5=b2c740efedc159745b9b31f88ff03dde"

SRC_URI = "git://github.com/TrustedFirmware-A/trusted-firmware-a.git;protocol=https;branch=lts-v2.10"
SRCREV = "bf6bc80a5f2d4a24ac5950314b3e79d61a7e6cee"
PV = "2.10.25"
