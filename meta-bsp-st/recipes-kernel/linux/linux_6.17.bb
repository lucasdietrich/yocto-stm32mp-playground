SUMMARIZE = "Linux kernel recipe for STMicroelectronics STM32MP1"
LICENSE = "MIT"