require optee-os.inc

SRCREV = "c2b0684fcd89929976a8726e6e3af922b48dd2c7"