require optee-os.inc

SRCREV = "753afbbee1682f5d16fd30e87b31058a4fd4f4b8"