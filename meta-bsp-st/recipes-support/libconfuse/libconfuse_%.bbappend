DEPENDS += "gettext-native flex-native"

BBCLASSEXTEND = "native nativesdk"