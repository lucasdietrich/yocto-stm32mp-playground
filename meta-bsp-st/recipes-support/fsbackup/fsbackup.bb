SUMMARY = "FS backup and restore tool"
DESCRIPTION = "Utilities to backup and restore user filesystems (data, config, etc ..)"

LICENSE = "CLOSED"

RDEPENDS:${PN} += "partclone zstd"